Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-20T08:06:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Oct 20 08:06:47 2023 * Host: DESKTOP-EKL9I0B * Database: C:\Users\WINDOW~1\AppData\Local\Temp\49aaeda2-b211-44b0-9e2b-55d4f2042267\e9912a2f-0b3a-4ac8-a8d5-2d878b924346\ifc * Database version: 5507 * Database creation date: Fri Oct 20 08:06:41 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Oct 20 08:06:42 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Oct 20 08:06:42 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: 103035BL00_REVIT:Aero-Lite WH Shower Toilet w Con.Cistern, 103035BL00_REVIT:Aero-Lite WH Shower Toilet w Con.Cistern:348313
In: Level 1
Type - Material: - (2), Polypropylene
Type - Pset_DuctConnection - ConnectionType: -
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_PipeConnection - ConnectionType: -
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Aero-Lite WH Shower Toilet w Con.Cistern
Material: Polypropylene, -
Pset_DistributionFlowElementCommon - Reference: Aero-Lite WH Shower Toilet w Con.Cistern; sets with these values: 2
Pset_DuctConnection - sets with these values: 2
